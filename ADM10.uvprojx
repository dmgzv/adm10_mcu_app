# Keil uVision project ADM10.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADM10_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427ZI, DEBUG
  c include: .\Sources;.\Sources\BSP;.\Sources\BSP\Common;.\Sources\BSP\Devices;.\Sources\CMSIS\Include;.\Sources\CMSIS\Device\ST\STM32F4xx\Include;.\Sources\FreeRTOS\Source\include;.\Sources\FreeRTOS\Source\CMSIS_RTOS;.\Sources\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Sources\STM32F4xx_HAL_Driver\Inc;.\Sources\STM32F4xx_HAL_Driver\Inc\Legacy;.\Sources\Profile;.\Sources\ProfileADM10;.\Sources\Utilities;.\Sources\LwIP;.\Sources\LwIP\system;.\Sources\LwIP\src\include;.\Sources\Shell;.\Sources\Web;.\Sources\TFTP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\ADM10_Debug.sct
  group CMSIS
    ./Sources/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Sources/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427xx.s
  group FreeRTOS
    ./Sources/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Sources/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./Sources/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Sources/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HAL
    ./Sources/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_nor.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group BSP/Devices
    ./Sources/BSP/Devices/: at45db641e.c s29gl01gs.c mt48lc16m16a2.c dim3r3400.c ucd90120a.c pca9536.c gdt080a.c pca9548a.c pmbus.c pcal6524.c sfp.c si5332.c ksz8895.c fpga_client_adm_2_5.c fpga_client_adm_10.c fpga_client_agg_2x10_bs.c fpga_client_agg_2x10_efec.c fpga_line_adm_10.c fpga_line_agg_2x10_bs.c fpga_line_agg_2x10_efec.c fpga_maxv.c fpga_iface.c
  group BSP/Common
    ./Sources/BSP/Common/: i2c.c spi.c clock.c uart.c watchdog.c flash.c eth.c log.c
  group BSP
    ./Sources/BSP/: bsp.c bsp_led.c bsp_flash.c bsp_sdram.c bsp_pwr_pin.c bsp_pwr_in.c bsp_pwr_seq.c bsp_pwr_cfg.c bsp_sfp.c bsp_sfp_pin.c bsp_sfp_i2c_switch.c bsp_clk.c bsp_eth_pin.c bsp_eth_sw.c bsp_fpga.c bsp_fpga_pwr.c bsp_fpga_flash.c bsp_eth.c
  group App
    ./Sources/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Profile
    ./Sources/Profile/: bootloader.c bootloader_protocol.c profile.c profile_flash.c profile_iface.c profile_protocol.c
  group ProfileADM10
    ./Sources/ProfileADM10/: profile_adm10.c profile_adm10_client.c profile_adm10_line.c profile_adm10_params.c profile_adm10_pg.c profile_adm10_text.c profile_adm10_values.c profile_adm10_xc.c profile_adm10_bitmsks.c profile_adm10_enums.c
  group Utilities
    ./Sources/Utilities/: als.c crc.c perf.c string_fnc.c
  group LwIP
    ./Sources/LwIP/system/OS/: sys_arch.c
    ./Sources/LwIP/src/netif/: ethernet.c
    ./Sources/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Sources/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./Sources/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Shell
    ./Sources/Shell/: shell.c shell_cmd.c shell_telnet.c shell_uart.c
  group Web
    ./Sources/Web/: http_server.c
  group TFTP
    ./Sources/TFTP/: tftp_bootloader.c tftp_bootloader_mcu.c tftp_client.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: ADM10_Release +hex
  AfterMake: D:\Horizon\ADM10\Software_MCU\Application\Objects\post_build.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427ZI
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\ADM10_Release.sct
